# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .;Libraries\CMSIS\Device\ST\STM32F4xx\Include;Libraries\CMSIS\Include;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\STM32_USB_Device_Library\Class\cdc\inc;Libraries\STM32_USB_Device_Library\Core\inc;Libraries\STM32_USB_OTG_Driver\inc;applications;components\httpclient;components\mjson;components\modem;drivers;rt-thread\components\dfs;rt-thread\components\dfs\include;rt-thread\components\drivers\include;rt-thread\components\drivers\usb\usbdevice;rt-thread\components\finsh;rt-thread\components\init;rt-thread\components\net\lwip-1.4.1\src;rt-thread\components\net\lwip-1.4.1\src\arch\include;rt-thread\components\net\lwip-1.4.1\src\include;rt-thread\components\net\lwip-1.4.1\src\include\ipv4;rt-thread\components\net\lwip-1.4.1\src\include\netif;rt-thread\components\net\lwip-1.4.1\src\netif\ppp;rt-thread\include;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;test\net\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\stm32_rom.sct
  link misc: --keep __fsym_* --keep __vsym_*
  group Applications
    applications/: application.c dhcp_server.c http.c modem_test.c ramdisk.c startup.c tcpserver.c telnet.c udpserver.c wifi_test.c
  group HTTPClient
    components/httpclient/: httpclient.c
  group M2MJSON
    components/mjson/: JSON_parser.c json.c mjson.c mjson_table.c
    components/mjson/test/: interface_mjson.c interface_test.c test.c test_mjson.c
  group Modem
    components/modem/module/: u-blox_LISA_U2XX.c ublox_neo6.c
    components/modem/: gps_data_parse.c modem.c utils.c
  group Drivers
    drivers/: board.c dp83848.c platform.c spi_flash_sst25vfxx.c stm32_dma_isr.c stm32_eth.c stm32_i2c.c stm32f20x_40x_spi.c stm32f4xx_dcd.c stm32f4xx_it.c swo.c usart.c usb_bsp.c uspi.c
    ./drivers/: sdio_sd.c
  group STM32_StdPeriph
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    Libraries/STM32_USB_Device_Library/Core/src/: usbd_ioreq.c
    Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group TestSuite
    test/iperf/: iperf_client.c
    test/modem/: dial.c gps.c ping.c switch.c tcp_multi_conn.c tcpclient.c udp_multi_conn.c udpclient.c
    test/usb/: serial_examples.c
  group test_net_auto
    test/net/target/auto/: case_log.c caselist.c t_case_icmp_reply.c t_case_tcp_connect1.c t_case_tcp_connect2.c t_case_tcp_data1.c t_case_tcp_data2.c t_case_tcp_data_validity.c t_case_tcp_stable.c t_case_udp_data1.c t_case_udp_data2.c t_case_udp_rx_speed.c t_case_udp_tx_speed.c test_cmd_server.c
  group Kernel
    rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    rt-thread/components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
    rt-thread/components/drivers/usb/usbdevice/core/: core.c usbdevice.c
    rt-thread/components/drivers/usb/usbdevice/class/: cdc_vcom.c mstorage.c
  group finsh
    rt-thread/components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Components
    rt-thread/components/init/: components.c
  group LwIP
    rt-thread/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    rt-thread/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    rt-thread/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    rt-thread/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
    rt-thread/components/net/lwip-1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
